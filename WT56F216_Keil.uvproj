# Keil uVision project WT56F216_Keil.uvproj, settings and files
target WT56F216 (MCS-51)
  device: see Atmel Atmel Wireless & uC
  output: WT56F216_Keil +hex
  c flags: Optimize=8 SizeSpeed=1
  group source
    ./code/: interrupt.c main.c REG_WT56F216_MemAlloc.c startup.a51 mcu.c Printf.c key.c ctrl.c Lcd.c
